RDEPENDS_${PN} += "gstreamer1.0-plugins-bad"
